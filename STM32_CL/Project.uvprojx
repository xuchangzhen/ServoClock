# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\System;.\User\App;.\User\BSP;.\User\Drivers;.\User\Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./System/: Delay.c Delay.h
  group User
    ./User/: Main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group BSP
    ./User/BSP/: MyADC.c MyI2C.c MyADC.h MyI2C.h MySPI.c MySPI.h MyTIM.c MyTIM.h MyUSART.c MyUSART.h LED_Show.c LED_Show.h MyKey.c MyKey.h
  group App
    ./User/App/: ServoCalibration.c ServoCalibration.h ServoRun.c ServoRun.h ClockTime.c ClockTime.h Dot.c Dot.h CommandParser.c CommandParser.h ServoClockApp.c ServoClockApp.h
  group Drivers
    ./User/Drivers/: W25Q64.c W25Q64.h PCA9685_L.c PCA9685_L.h PCA9685_R.c PCA9685_R.h PCA9685.c PCA9685.h
  group Test
    ./User/Test/: USART_Test.c USART_Test.h
